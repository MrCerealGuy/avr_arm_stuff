# Keil uVision project LandTiger.uvproj, settings and files
target LandTiger V2.0 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LandTiger +hex
  c flags: Optim=1 OneElfS=1
  c include: ..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\NXP\LPC17xx;..\USER;..\USER\SPI_Flash;..\USER\GLCD
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group User
    ../USER/: main.c
  group GLCD
    ../USER/GLCD/: GLCD.c HzLib.c AsciiLib.c
  group SPI Flash
    ../USER/SPI_Flash/: FlashDriver.c SST25VF016B.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
  group Doc
    ../: readme.txt
